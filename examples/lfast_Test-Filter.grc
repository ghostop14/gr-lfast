options:
  parameters:
    generate_options: qt_gui
    id: test_lfastfilter
    output_language: python
  states: {}

blocks:
- name: cutoff_freq
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10.7622e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/sdr/gnuradio/gnuradio_recordings/atsc/gnuradio_atsc_593MHz_6.2MSPS.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.fft import window
  states: {}
- name: lfast_MTFIRLowPassFilterXX_0
  id: lfast_MTFIRLowPassFilterXX
  parameters:
    beta: '6.76'
    cutoff_freq: cutoff_freq
    gain: '1'
    nthreads: '4'
    samp_rate: samp_rate
    type: CCF
    width: cutoff_freq*.2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: cutoff_freq*.2
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"green"'
    color2: '"blue"'
    color3: '"red"'
    fc: 593e6
    fftsize: '1024'
    label1: Raw
    label2: GNURadio
    label3: LFast
    name: '"Filtered Signal"'
    nconnections: '3'
    showports: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', lfast_MTFIRLowPassFilterXX_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [lfast_MTFIRLowPassFilterXX_0, '0', qtgui_freq_sink_x_0, '2']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae

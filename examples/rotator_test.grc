options:
  parameters:
    generate_options: qt_gui
    id: test_rotator
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 162.425e6
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    orient: Qt.Horizontal
    start: '0'
    step: 50e3
    stop: 800e3
    value: 500e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi*(offset)/samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: filerepeater_file_repeater_ex_0
  id: filerepeater_file_repeater_ex
  parameters:
    complexconv: '0'
    delayFirstStart: '0.0'
    file: /opt/sdr/gnuradio/gnuradio_recordings/NOAA_weather_radio_162.425MHz_NBFM_600KSPS_NoFilter.iq
    repeat: 'True'
    repeat_delay: '0'
    repeat_times: '0'
    type: complex
    verbose: 'False'
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: lfast_freq_shift_0
  id: lfast_freq_shift
  parameters:
    freq: offset
    sample_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,0,1,3
    label1: Rotator
    label2: Mixer
    label3: Convenience Wrapper
    nconnections: '3'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0, '0', blocks_rotator_cc_0, '0']
- [blocks_throttle_0, '0', lfast_freq_shift_0, '0']
- [filerepeater_file_repeater_ex_0, '0', blocks_throttle_0, '0']
- [lfast_freq_shift_0, '0', qtgui_freq_sink_x_0, '2']

metadata:
  file_format: 1
